# Keil uVision project F401Standard.uvprojx, settings and files
target F401Standard (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: F401Standard +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xC
  c include: ../Core/Inc;                                                                                            ../Drivers/STM32F4xx_HAL_Driver/Inc;                                                                                            ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;                                                                                            ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;                                                                                            ../Drivers/CMSIS/Include;                                                                                            ..\App;                                                                                            ..\Bsp;                                                                                            ..\UserLib
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c iwdg.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ./: startup_stm32f401xc.s
    ../Core/Src/: system_stm32f4xx.c
  group UserLib
    ../UserLib/: pid.c fifo.c menu.c Oscilloscope.c
  group Bsp
    ../Bsp/: bsp_gpio.c bsp_delay.c bsp_usart.c bsp_lcd.c bsp_lcd_init.c bsp_spi.c bsp_flash.c bsp_ec11.c socket.c w5500.c w5500_conf.c
  group App
    ../App/: appMain.c appMenu.c angle_length.c openmv.c udp_demo.c
software components: CMSIS:CORE 4.3.0
